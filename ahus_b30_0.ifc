Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: ahus_b30.ifc.ifc
Time: 2016-09-26T09:58:51
Author: Supplier
Organization: BIMobject
Written by: IFC Engine DLL 2015
Made in: BIMobject-Lena
Authorization: Full Scope

# IfcBuildingStorey
Elevation: 0 m

# IfcFurnishingElement: ￃﾅhus B30
ePset_BIMobject_Lena - Seat Material: Black Leather; Table Material: Oak; Leg brackets colour: Black RAL 9005; LOD: 300
ePset_BIMobject_BO - ProductName (BO_prodinfo): ￃﾅhus B30; SKU (BO_prodsku): B30; ManufacturName (BO_Manufac): Blￃﾥ Station; ProductFamily (BO_prodfam): Easy Chairs; ProductGroup (BO_prodgroup): ￃﾅhus; ManufacturCountry (BO_mancont): Sweden; DesignCountry (BO_designcont): Sweden; PublishDate (BO_publisdat): 9/6/2016; EditionNumber (BO_edinum): 1; Width (BO_width): 830; Height (BO_height): 720; Depth (BO_depth): 800; Weight (BO_weight): 15.7; QR (BO_boqrurl): http://bimobject.com/blastation/product/B30; ProductDataUrl (BO_prodaturl): bimobject.com/blastation/product/B30; MaterialMain (BO_mainmat): Upholstery; MaterialSecondary (BO_secmat): Steel; BimObjectCategory (BO_bocat): Armchairs; IfcClassification (BO_ifcclas): Furniture; Uniclass14Code (BO_uniclass_1_4_code): L8211; Uniclass14Description (BO_uniclass_1_4_desc): Furniture; NBSReference (BO_nbs_ref): 31-12; NBSReferenceDescription (BO_nbs_desc): Chairs, Seats And Bench Seating; MasterFormat2014Code (BO_masterformat2014_code): 12 00 00; MasterFormat2014Description (BO_masterformat2014_name): Furnishings; RegionEurope (BO_europe): All; RegionNorthAmerica (BO_northamerica): All; RegionSouthAmerica (BO_southamerica): All; RegionMiddleEast (BO_middleeast): All; RegionAsia (BO_asia): All; RegionOceania (BO_oceania): All; RegionAfrica (BO_africa): All; RegionAntarctica (BO_antarctica): All
